# IAR project STWinSampleApp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9ZI ST STM32L4R9ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER; STM32_STWIN; SAMPLE_WAIT_OPTION=(20 * NX_IP_PERIODIC_RATE)
  ICCARM.CCIncludePath2: ..\..\..\Common\threadx\common\inc; ..\..\..\Common\threadx\ports\cortex_m4\iar\inc; ..\..\..\Common\netxduo\; ..\..\..\Common\netxduo\common; ..\..\..\Common\netxduo\nx_secure\ports; ..\..\..\Common\netxduo\crypto_libraries\inc; ..\..\..\Common\netxduo\common\; ..\..\..\Common\netxduo\addons\cloud; ..\..\..\Common\netxduo\addons\dns; ..\..\..\Common\netxduo\addons\mqtt; ..\..\..\Common\netxduo\addons\sntp; ..\..\..\Common\netxduo\nx_secure\inc; ..\..\..\Common\netxduo\nx_secure\ports; ..\..\..\Common\netxduo\addons\azure_iot\azure-sdk-for-c\sdk\inc; ..\..\..\Common\netxduo\addons\azure_iot\; ..\stm32l4xx_lib\; ..\..\..\Common\stm32l4xx_lib\; ..\..\..\Common\stm32l4xx_lib\CMSIS\Include; ..\..\..\Common\stm32l4xx_lib\CMSIS\Device\ST\STM32L4xx\Include; ; ..\stm32l4xx_lib\Components\Common; ..\stm32l4xx_lib\Components\hts221; ..\stm32l4xx_lib\Components\iis2mdc; ..\stm32l4xx_lib\Components\ism330dhcx; ..\stm32l4xx_lib\Components\lps22hh
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sample.bin
  ILINK.IlinkOutputFile: sample.out
  ILINK.IlinkIcfFile: stm32l4r9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Lib
    ../netxduo/Debug/Exe/: netxduo.a
    ../stm32l4xx_lib/Debug/Exe/: stm32l4xx_lib.a
    ../threadx/Debug/Exe/: threadx.a
  group Sample
    ./: board_setup.c DeviceInfoComponent.c es_wifi.c main.c MetaDataManager.c nx_azure_iot_cert.c nx_azure_iot_ciphersuites.c sample_config.h sample_device_identity.c startup_stm32l4r9xx.s StdComponent.c STWinSampleApp.c tx_initialize_low_level.s wifi.c
