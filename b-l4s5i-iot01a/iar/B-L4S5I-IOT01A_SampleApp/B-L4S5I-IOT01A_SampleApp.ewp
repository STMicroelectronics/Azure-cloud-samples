# IAR project B-L4S5I-IOT01A_SampleApp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4S5VI ST STM32L4S5VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4S5xx; USE_HAL_DRIVER; SAMPLE_WAIT_OPTION=(20 * NX_IP_PERIODIC_RATE)
  ICCARM.CCIncludePath2: ..\..\..\Common\threadx\common\inc; ..\..\..\Common\threadx\ports\cortex_m4\iar\inc; ..\..\..\Common\netxduo\; ..\..\..\Common\netxduo\common; ..\..\..\Common\netxduo\nx_secure\ports; ..\..\..\Common\netxduo\crypto_libraries\inc; ..\..\..\Common\netxduo\common\; ..\..\..\Common\netxduo\addons\cloud; ..\..\..\Common\netxduo\addons\dns; ..\..\..\Common\netxduo\addons\mqtt; ..\..\..\Common\netxduo\addons\sntp; ..\..\..\Common\netxduo\nx_secure\inc; ..\..\..\Common\netxduo\nx_secure\ports; ..\..\..\Common\stm32l4xx_lib\; ..\..\..\Common\stm32l4xx_lib\CMSIS\Include; ..\..\..\Common\stm32l4xx_lib\CMSIS\Device\ST\STM32L4xx\Include; ; ..\..\..\Common\netxduo\addons\azure_iot\azure-sdk-for-c\sdk\inc; ..\..\..\Common\netxduo\addons\azure_iot\; ..\stm32l4xx_lib\; ..\stm32l4xx_lib\B-L4S5I-IOT01A; ..\stm32l4xx_lib\Components\vl53l0x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: B-L4S5I-IOT01A_SampleApp.bin
  ILINK.IlinkOutputFile: B-L4S5I-IOT01A_SampleApp.out
  ILINK.IlinkIcfFile: stm32l4s5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Common Source
    ./: board_setup.c es_wifi.c MetaDataManager.c startup_stm32l4s5xx.s tx_initialize_low_level.s wifi.c
  group Lib
    ../netxduo/Debug/Exe/: netxduo.a
    ../stm32l4xx_lib/Debug/Exe/: stm32l4xx_lib.a
    ../threadx/Debug/Exe/: threadx.a
  group Sample
    ./: B-L4S5I-IOT01A_SampleApp.c DeviceInfoComponent.c main.c nx_azure_iot_cert.c nx_azure_iot_ciphersuites.c sample_config.h sample_device_identity.c StdComponent.c
